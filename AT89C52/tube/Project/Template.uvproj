# Keil uVision project Template.uvproj, settings and files
target Template (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User
  group Startup
    ../Startup/: STARTUP.A51
  group User
    ../User/: main.c bsp_delay.c bsp_tube.c
